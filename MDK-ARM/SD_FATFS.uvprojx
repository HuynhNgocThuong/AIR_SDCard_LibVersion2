# Keil uVision project SD_FATFS.uvprojx, settings and files
target SD_FATFS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SD_FATFS
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include; ../Middlewares/Third_Party/FatFs/src; ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_flash.c stm32f1xx_hal_tim.c stm32f1xx_hal_dma.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_spi.c stm32f1xx_hal_uart.c stm32f1xx_hal_gpio.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c
  group Application/User
    ../Src/: user_diskio.c stm32f1xx_hal_msp.c main.c fatfs.c stm32f1xx_it.c sd.c
    ../Middlewares/Third_Party/FatFs/src/option/: ccsbcs.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c diskio.c ff.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.1.0
